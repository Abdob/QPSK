<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>C:\Users\Jevin\Documents\SDR\QPSK\MatlabScripts\grReceived.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\Users\Jevin\Documents\SDR\QPSK\FlowCharts\message.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

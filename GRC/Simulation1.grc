<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>201</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>157</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-.5-.5j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>0.5 + 0.5j</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_char</key>
<param><key>id</key><value>blocks_complex_to_interleaved_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/received.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/message.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>-.5 - .5j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_diff_phasor_cc</key>
<param><key>id</key><value>digital_diff_phasor_cc_0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>32</value></param>
<param><key>taps</key><value>(0.00440055455,0.00369636371,0.00288035366,0.00196752341,0.00097544594,-0.00007603314,-0.00116515380,-0.00226865078,-0.00336220653,-0.00442093971,-0.00541992003,-0.00633469948,-0.00714184925,-0.00781949132,-0.00834781348,-0.00870955655,-0.00889046275,-0.00887967491,-0.00867007640,-0.00825856325,-0.00764624052,-0.00683853653,-0.00584523005,-0.00468038723,-0.00336220653,-0.00191277216,-0.00035771798,0.00127419387,0.00295157398,0.00464097829,0.00630754317,0.00791567182,0.00942975975,0.01081494560,0.01203787299,0.01306744804,0.01387557704,0.01443786842,0.01473428352,0.01474972115,0.01447452151,0.01390487659,0.01304313506,0.01189799183,0.01048455404,0.00882427755,0.00694477036,0.00487946178,0.00266713883,0.00035135400,-0.00202028889,-0.00439696136,-0.00672553752,-0.00895160771,-0.01102056194,-0.01287872475,-0.01447452151,-0.01575965450,-0.01669026650,-0.01722806878,-0.01734141025,-0.01700626475,-0.01620711404,-0.01493770537,-0.01320166365,-0.01101294051,-0.00839608467,-0.00538632082,-0.00202942704,0.00161859578,0.00549206559,0.00951637131,0.01360893121,0.01768034922,0.02163575726,0.02537632781,0.02880093752,0.03180795922,0.03429715652,0.03617165278,0.03733994357,0.03771792007,0.03723086956,0.03581541809,0.03342138025,0.03001348157,0.02557291932,0.02009872974,0.01360893121,0.00614141585,-0.00224543488,-0.01147243148,-0.02143957111,-0.03202635803,-0.04309245702,-0.05447868220,-0.06600831826,-0.07748876586,-0.08871349760,-0.09946430585,-0.10951381836,-0.11862825310,-0.12657037898,-0.13310264520,-0.13799043843,-0.14100542377,-0.14192892333,-0.14055528424,-0.13669518705,-0.13017884511,-0.12085904595,-0.10861398686,-0.09334985892,-0.07500313632,-0.05354253128,-0.02897057889,-0.00132482083,0.02932143773,0.06285881818,0.09914201961,0.13799043843,0.17918925776,0.22249100085,0.26761753607,0.31426251469,0.36209421583,0.41075876725,0.45988370455,0.50908182639,0.55795529848,0.60609995506,0.65310974344,0.69858125430,0.74211827899,0.78333633403,0.82186709290,0.85736266612,0.88949967243,0.91798304598,0.94254952835,0.96297079776,0.97905619301,0.99065499493,0.99765823407,1.00000000000,0.99765823407,0.99065499493,0.97905619301,0.96297079776,0.94254952835,0.91798304598,0.88949967243,0.85736266612,0.82186709290,0.78333633403,0.74211827899,0.69858125430,0.65310974344,0.60609995506,0.55795529848,0.50908182639,0.45988370455,0.41075876725,0.36209421583,0.31426251469,0.26761753607,0.22249100085,0.17918925776,0.13799043843,0.09914201961,0.06285881818,0.02932143773,-0.00132482083,-0.02897057889,-0.05354253128,-0.07500313632,-0.09334985892,-0.10861398686,-0.12085904595,-0.13017884511,-0.13669518705,-0.14055528424,-0.14192892333,-0.14100542377,-0.13799043843,-0.13310264520,-0.12657037898,-0.11862825310,-0.10951381836,-0.09946430585,-0.08871349760,-0.07748876586,-0.06600831826,-0.05447868220,-0.04309245702,-0.03202635803,-0.02143957111,-0.01147243148,-0.00224543488,0.00614141585,0.01360893121,0.02009872974,0.02557291932,0.03001348157,0.03342138025,0.03581541809,0.03723086956,0.03771792007,0.03733994357,0.03617165278,0.03429715652,0.03180795922,0.02880093752,0.02537632781,0.02163575726,0.01768034922,0.01360893121,0.00951637131,0.00549206559,0.00161859578,-0.00202942704,-0.00538632082,-0.00839608467,-0.01101294051,-0.01320166365,-0.01493770537,-0.01620711404,-0.01700626475,-0.01734141025,-0.01722806878,-0.01669026650,-0.01575965450,-0.01447452151,-0.01287872475,-0.01102056194,-0.00895160771,-0.00672553752,-0.00439696136,-0.00202028889,0.00035135400,0.00266713883,0.00487946178,0.00694477036,0.00882427755,0.01048455404,0.01189799183,0.01304313506,0.01390487659,0.01447452151,0.01474972115,0.01473428352,0.01443786842,0.01387557704,0.01306744804,0.01203787299,0.01081494560,0.00942975975,0.00791567182,0.00630754317,0.00464097829,0.00295157398,0.00127419387,-0.00035771798,-0.00191277216,-0.00336220653,-0.00468038723,-0.00584523005,-0.00683853653,-0.00764624052,-0.00825856325,-0.00867007640,-0.00887967491,-0.00889046275,-0.00870955655,-0.00834781348,-0.00781949132,-0.00714184925,-0.00633469948,-0.00541992003,-0.00442093971,-0.00336220653,-0.00226865078,-0.00116515380,-0.00007603314,0.00097544594,0.00196752341,0.00288035366,0.00369636371,0.00440055455)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>32</value></param>
<param><key>taps</key><value>(0.00440055455,0.00369636371,0.00288035366,0.00196752341,0.00097544594,-0.00007603314,-0.00116515380,-0.00226865078,-0.00336220653,-0.00442093971,-0.00541992003,-0.00633469948,-0.00714184925,-0.00781949132,-0.00834781348,-0.00870955655,-0.00889046275,-0.00887967491,-0.00867007640,-0.00825856325,-0.00764624052,-0.00683853653,-0.00584523005,-0.00468038723,-0.00336220653,-0.00191277216,-0.00035771798,0.00127419387,0.00295157398,0.00464097829,0.00630754317,0.00791567182,0.00942975975,0.01081494560,0.01203787299,0.01306744804,0.01387557704,0.01443786842,0.01473428352,0.01474972115,0.01447452151,0.01390487659,0.01304313506,0.01189799183,0.01048455404,0.00882427755,0.00694477036,0.00487946178,0.00266713883,0.00035135400,-0.00202028889,-0.00439696136,-0.00672553752,-0.00895160771,-0.01102056194,-0.01287872475,-0.01447452151,-0.01575965450,-0.01669026650,-0.01722806878,-0.01734141025,-0.01700626475,-0.01620711404,-0.01493770537,-0.01320166365,-0.01101294051,-0.00839608467,-0.00538632082,-0.00202942704,0.00161859578,0.00549206559,0.00951637131,0.01360893121,0.01768034922,0.02163575726,0.02537632781,0.02880093752,0.03180795922,0.03429715652,0.03617165278,0.03733994357,0.03771792007,0.03723086956,0.03581541809,0.03342138025,0.03001348157,0.02557291932,0.02009872974,0.01360893121,0.00614141585,-0.00224543488,-0.01147243148,-0.02143957111,-0.03202635803,-0.04309245702,-0.05447868220,-0.06600831826,-0.07748876586,-0.08871349760,-0.09946430585,-0.10951381836,-0.11862825310,-0.12657037898,-0.13310264520,-0.13799043843,-0.14100542377,-0.14192892333,-0.14055528424,-0.13669518705,-0.13017884511,-0.12085904595,-0.10861398686,-0.09334985892,-0.07500313632,-0.05354253128,-0.02897057889,-0.00132482083,0.02932143773,0.06285881818,0.09914201961,0.13799043843,0.17918925776,0.22249100085,0.26761753607,0.31426251469,0.36209421583,0.41075876725,0.45988370455,0.50908182639,0.55795529848,0.60609995506,0.65310974344,0.69858125430,0.74211827899,0.78333633403,0.82186709290,0.85736266612,0.88949967243,0.91798304598,0.94254952835,0.96297079776,0.97905619301,0.99065499493,0.99765823407,1.00000000000,0.99765823407,0.99065499493,0.97905619301,0.96297079776,0.94254952835,0.91798304598,0.88949967243,0.85736266612,0.82186709290,0.78333633403,0.74211827899,0.69858125430,0.65310974344,0.60609995506,0.55795529848,0.50908182639,0.45988370455,0.41075876725,0.36209421583,0.31426251469,0.26761753607,0.22249100085,0.17918925776,0.13799043843,0.09914201961,0.06285881818,0.02932143773,-0.00132482083,-0.02897057889,-0.05354253128,-0.07500313632,-0.09334985892,-0.10861398686,-0.12085904595,-0.13017884511,-0.13669518705,-0.14055528424,-0.14192892333,-0.14100542377,-0.13799043843,-0.13310264520,-0.12657037898,-0.11862825310,-0.10951381836,-0.09946430585,-0.08871349760,-0.07748876586,-0.06600831826,-0.05447868220,-0.04309245702,-0.03202635803,-0.02143957111,-0.01147243148,-0.00224543488,0.00614141585,0.01360893121,0.02009872974,0.02557291932,0.03001348157,0.03342138025,0.03581541809,0.03723086956,0.03771792007,0.03733994357,0.03617165278,0.03429715652,0.03180795922,0.02880093752,0.02537632781,0.02163575726,0.01768034922,0.01360893121,0.00951637131,0.00549206559,0.00161859578,-0.00202942704,-0.00538632082,-0.00839608467,-0.01101294051,-0.01320166365,-0.01493770537,-0.01620711404,-0.01700626475,-0.01734141025,-0.01722806878,-0.01669026650,-0.01575965450,-0.01447452151,-0.01287872475,-0.01102056194,-0.00895160771,-0.00672553752,-0.00439696136,-0.00202028889,0.00035135400,0.00266713883,0.00487946178,0.00694477036,0.00882427755,0.01048455404,0.01189799183,0.01304313506,0.01390487659,0.01447452151,0.01474972115,0.01473428352,0.01443786842,0.01387557704,0.01306744804,0.01203787299,0.01081494560,0.00942975975,0.00791567182,0.00630754317,0.00464097829,0.00295157398,0.00127419387,-0.00035771798,-0.00191277216,-0.00336220653,-0.00468038723,-0.00584523005,-0.00683853653,-0.00764624052,-0.00825856325,-0.00867007640,-0.00887967491,-0.00889046275,-0.00870955655,-0.00834781348,-0.00781949132,-0.00714184925,-0.00633469948,-0.00541992003,-0.00442093971,-0.00336220653,-0.00226865078,-0.00116515380,-0.00007603314,0.00097544594,0.00196752341,0.00288035366,0.00369636371,0.00440055455)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qpsk_diff_encoder</key>
<param><key>id</key><value>qpsk_diff_encoder_0</value></param>
<param><key>altern</key><value>True</value></param>
</block>
<block>
<key>qpsk_symbol_decision</key>
<param><key>id</key><value>qpsk_symbol_decision_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_complex_to_interleaved_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_char_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qpsk_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qpsk_symbol_decision_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_phasor_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_diff_phasor_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_diff_encoder_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_symbol_decision_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

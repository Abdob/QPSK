<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>201</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>157</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-.5-.5j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>const</key><value>0.5 + 0.5j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_char</key>
<param><key>id</key><value>blocks_complex_to_interleaved_char_0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>6</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/received.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/rx.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/message.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>-.5 - .5j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_diff_phasor_cc</key>
<param><key>id</key><value>digital_diff_phasor_cc_0</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>32</value></param>
<param><key>taps</key><value>(0.000884237139,0.000742738678,0.000578771528,0.000395349552,0.000196003825,-0.000015277920,-0.000234123278,-0.000455857381,-0.000675593917,-0.000888333285,-0.001089066053,-0.001272879696,-0.001435066484,-0.001571230297,-0.001677390116,-0.001750077921,-0.001786428791,-0.001784261107,-0.001742144872,-0.001659456383,-0.001536417687,-0.001374119535,-0.001174526855,-0.000940466063,-0.000675593917,-0.000384347964,-0.000071879015,0.000256033537,0.000593082372,0.000932547323,0.001267422971,0.001590556581,0.001894793869,0.002173129873,0.002418862041,0.002625742444,0.002788125995,0.002901111510,0.002960672468,0.002963774469,0.002908476497,0.002794013379,0.002620857051,0.002390754649,0.002106741765,0.001773129691,0.001395465913,0.000980467637,0.000535928637,0.000070600250,-0.000405952125,-0.000883515131,-0.001351413778,-0.001798715116,-0.002214445939,-0.002587820828,-0.002908476497,-0.003166708115,-0.003353703113,-0.003461767845,-0.003484542416,-0.003417199061,-0.003256619587,-0.003001547579,-0.002652711416,-0.002212914506,-0.001687089615,-0.001082314708,-0.000407788323,0.000325236851,0.001103562814,0.001912197392,0.002734546806,0.003552648019,0.004347438458,0.005099059955,0.005787193020,0.006391416927,0.006891590411,0.007268247306,0.007503000923,0.007578950637,0.007481083848,0.007196666339,0.006715613976,0.006030838786,0.005138562594,0.004038591744,0.002734546806,0.001234041737,-0.000451192433,-0.002305243548,-0.004308017272,-0.006435301473,-0.008658897521,-0.010946818977,-0.013263557080,-0.015570411368,-0.017825882709,-0.019986124972,-0.022005450511,-0.023836883710,-0.025432755907,-0.026745334203,-0.027727475942,-0.028333300045,-0.028518865887,-0.028242850060,-0.027467211159,-0.026157832651,-0.024285134007,-0.021824640474,-0.018757502308,-0.015070954781,-0.010758711001,-0.005821280361,-0.000266206399,0.005891781114,0.012630703900,0.019921365530,0.027727475942,0.036005870336,0.044706821310,0.053774441748,0.063147174650,0.072758364800,0.082536905937,0.092407955936,0.102293711466,0.112114232633,0.121788307318,0.131234344240,0.140371283274,0.149119511184,0.157401770757,0.165144051320,0.172276448781,0.178733983661,0.184457366120,0.189393697627,0.193497099737,0.196729261436,0.199059897563,0.200467112057,0.200937661025,0.200467112057,0.199059897563,0.196729261436,0.193497099737,0.189393697627,0.184457366120,0.178733983661,0.172276448781,0.165144051320,0.157401770757,0.149119511184,0.140371283274,0.131234344240,0.121788307318,0.112114232633,0.102293711466,0.092407955936,0.082536905937,0.072758364800,0.063147174650,0.053774441748,0.044706821310,0.036005870336,0.027727475942,0.019921365530,0.012630703900,0.005891781114,-0.000266206399,-0.005821280361,-0.010758711001,-0.015070954781,-0.018757502308,-0.021824640474,-0.024285134007,-0.026157832651,-0.027467211159,-0.028242850060,-0.028518865887,-0.028333300045,-0.027727475942,-0.026745334203,-0.025432755907,-0.023836883710,-0.022005450511,-0.019986124972,-0.017825882709,-0.015570411368,-0.013263557080,-0.010946818977,-0.008658897521,-0.006435301473,-0.004308017272,-0.002305243548,-0.000451192433,0.001234041737,0.002734546806,0.004038591744,0.005138562594,0.006030838786,0.006715613976,0.007196666339,0.007481083848,0.007578950637,0.007503000923,0.007268247306,0.006891590411,0.006391416927,0.005787193020,0.005099059955,0.004347438458,0.003552648019,0.002734546806,0.001912197392,0.001103562814,0.000325236851,-0.000407788323,-0.001082314708,-0.001687089615,-0.002212914506,-0.002652711416,-0.003001547579,-0.003256619587,-0.003417199061,-0.003484542416,-0.003461767845,-0.003353703113,-0.003166708115,-0.002908476497,-0.002587820828,-0.002214445939,-0.001798715116,-0.001351413778,-0.000883515131,-0.000405952125,0.000070600250,0.000535928637,0.000980467637,0.001395465913,0.001773129691,0.002106741765,0.002390754649,0.002620857051,0.002794013379,0.002908476497,0.002963774469,0.002960672468,0.002901111510,0.002788125995,0.002625742444,0.002418862041,0.002173129873,0.001894793869,0.001590556581,0.001267422971,0.000932547323,0.000593082372,0.000256033537,-0.000071879015,-0.000384347964,-0.000675593917,-0.000940466063,-0.001174526855,-0.001374119535,-0.001536417687,-0.001659456383,-0.001742144872,-0.001784261107,-0.001786428791,-0.001750077921,-0.001677390116,-0.001571230297,-0.001435066484,-0.001272879696,-0.001089066053,-0.000888333285,-0.000675593917,-0.000455857381,-0.000234123278,-0.000015277920,0.000196003825,0.000395349552,0.000578771528,0.000742738678,0.000884237139)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>32</value></param>
<param><key>taps</key><value>(0.000884237139,0.000742738678,0.000578771528,0.000395349552,0.000196003825,-0.000015277920,-0.000234123278,-0.000455857381,-0.000675593917,-0.000888333285,-0.001089066053,-0.001272879696,-0.001435066484,-0.001571230297,-0.001677390116,-0.001750077921,-0.001786428791,-0.001784261107,-0.001742144872,-0.001659456383,-0.001536417687,-0.001374119535,-0.001174526855,-0.000940466063,-0.000675593917,-0.000384347964,-0.000071879015,0.000256033537,0.000593082372,0.000932547323,0.001267422971,0.001590556581,0.001894793869,0.002173129873,0.002418862041,0.002625742444,0.002788125995,0.002901111510,0.002960672468,0.002963774469,0.002908476497,0.002794013379,0.002620857051,0.002390754649,0.002106741765,0.001773129691,0.001395465913,0.000980467637,0.000535928637,0.000070600250,-0.000405952125,-0.000883515131,-0.001351413778,-0.001798715116,-0.002214445939,-0.002587820828,-0.002908476497,-0.003166708115,-0.003353703113,-0.003461767845,-0.003484542416,-0.003417199061,-0.003256619587,-0.003001547579,-0.002652711416,-0.002212914506,-0.001687089615,-0.001082314708,-0.000407788323,0.000325236851,0.001103562814,0.001912197392,0.002734546806,0.003552648019,0.004347438458,0.005099059955,0.005787193020,0.006391416927,0.006891590411,0.007268247306,0.007503000923,0.007578950637,0.007481083848,0.007196666339,0.006715613976,0.006030838786,0.005138562594,0.004038591744,0.002734546806,0.001234041737,-0.000451192433,-0.002305243548,-0.004308017272,-0.006435301473,-0.008658897521,-0.010946818977,-0.013263557080,-0.015570411368,-0.017825882709,-0.019986124972,-0.022005450511,-0.023836883710,-0.025432755907,-0.026745334203,-0.027727475942,-0.028333300045,-0.028518865887,-0.028242850060,-0.027467211159,-0.026157832651,-0.024285134007,-0.021824640474,-0.018757502308,-0.015070954781,-0.010758711001,-0.005821280361,-0.000266206399,0.005891781114,0.012630703900,0.019921365530,0.027727475942,0.036005870336,0.044706821310,0.053774441748,0.063147174650,0.072758364800,0.082536905937,0.092407955936,0.102293711466,0.112114232633,0.121788307318,0.131234344240,0.140371283274,0.149119511184,0.157401770757,0.165144051320,0.172276448781,0.178733983661,0.184457366120,0.189393697627,0.193497099737,0.196729261436,0.199059897563,0.200467112057,0.200937661025,0.200467112057,0.199059897563,0.196729261436,0.193497099737,0.189393697627,0.184457366120,0.178733983661,0.172276448781,0.165144051320,0.157401770757,0.149119511184,0.140371283274,0.131234344240,0.121788307318,0.112114232633,0.102293711466,0.092407955936,0.082536905937,0.072758364800,0.063147174650,0.053774441748,0.044706821310,0.036005870336,0.027727475942,0.019921365530,0.012630703900,0.005891781114,-0.000266206399,-0.005821280361,-0.010758711001,-0.015070954781,-0.018757502308,-0.021824640474,-0.024285134007,-0.026157832651,-0.027467211159,-0.028242850060,-0.028518865887,-0.028333300045,-0.027727475942,-0.026745334203,-0.025432755907,-0.023836883710,-0.022005450511,-0.019986124972,-0.017825882709,-0.015570411368,-0.013263557080,-0.010946818977,-0.008658897521,-0.006435301473,-0.004308017272,-0.002305243548,-0.000451192433,0.001234041737,0.002734546806,0.004038591744,0.005138562594,0.006030838786,0.006715613976,0.007196666339,0.007481083848,0.007578950637,0.007503000923,0.007268247306,0.006891590411,0.006391416927,0.005787193020,0.005099059955,0.004347438458,0.003552648019,0.002734546806,0.001912197392,0.001103562814,0.000325236851,-0.000407788323,-0.001082314708,-0.001687089615,-0.002212914506,-0.002652711416,-0.003001547579,-0.003256619587,-0.003417199061,-0.003484542416,-0.003461767845,-0.003353703113,-0.003166708115,-0.002908476497,-0.002587820828,-0.002214445939,-0.001798715116,-0.001351413778,-0.000883515131,-0.000405952125,0.000070600250,0.000535928637,0.000980467637,0.001395465913,0.001773129691,0.002106741765,0.002390754649,0.002620857051,0.002794013379,0.002908476497,0.002963774469,0.002960672468,0.002901111510,0.002788125995,0.002625742444,0.002418862041,0.002173129873,0.001894793869,0.001590556581,0.001267422971,0.000932547323,0.000593082372,0.000256033537,-0.000071879015,-0.000384347964,-0.000675593917,-0.000940466063,-0.001174526855,-0.001374119535,-0.001536417687,-0.001659456383,-0.001742144872,-0.001784261107,-0.001786428791,-0.001750077921,-0.001677390116,-0.001571230297,-0.001435066484,-0.001272879696,-0.001089066053,-0.000888333285,-0.000675593917,-0.000455857381,-0.000234123278,-0.000015277920,0.000196003825,0.000395349552,0.000578771528,0.000742738678,0.000884237139)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qpsk_diff_encoder</key>
<param><key>id</key><value>qpsk_diff_encoder_0</value></param>
<param><key>altern</key><value>True</value></param>
</block>
<block>
<key>qpsk_symbol_decision</key>
<param><key>id</key><value>qpsk_symbol_decision_0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_complex_to_interleaved_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_char_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qpsk_diff_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qpsk_symbol_decision_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_phasor_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>digital_diff_phasor_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_diff_encoder_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_symbol_decision_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/received.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/ichar.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/foci2/Documents/SDR/QPSK/GRC/message.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>qpsk_de_randomizer</key>
<param><key>id</key><value>qpsk_de_randomizer_0</value></param>
</block>
<block>
<key>qpsk_de_randomizer</key>
<param><key>id</key><value>qpsk_de_randomizer_1</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>qpsk_de_randomizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_de_randomizer_0</source_block_id><sink_block_id>qpsk_de_randomizer_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_de_randomizer_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qpsk_de_randomizer_1</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
